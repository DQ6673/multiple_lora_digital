# Keil uVision project master.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\delay;..\USER;..\CORE;..\HARDWARE\SX127X;..\HARDWARE\IIC;..\HARDWARE\DWIN;..\HARDWARE\24Cxx;..\HARDWARE\RELAY;..\HARDWARE\LORA;..\HARDWARE\TIM
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24Cxx/: 24cxx.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/LORA/: lora.c
    ../HARDWARE/DWIN/: DWIN_APP.c DWIN_SET.c
    ../HARDWARE/TIM/: tim.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c syscfg.c main.c
  group SX127X
    ../HARDWARE/SX127X/HAL/: SX127x_hal.c
    ../HARDWARE/SX127X/radio/: sx127x_driver.c
    ../HARDWARE/SX127X/example/: example_CAD.c example_RX.c example_TX.c
